## board/yhup/pt1570_r10/Kconfig
```kconfig
# SPDX-License-Identifier: GPL-2.0+
if TARGET_YHUP_PT1570_R10
config SYS_BOARD
	default "pt1570_r10"
config SYS_VENDOR
	default "yhup"
endif
```
